# Keil uVision project 000 Kibot1_51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51_duoji20180919 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group src
    ./src/: z_main.c z_adc.c z_delay.c z_global.c z_gpio.c z_ps2.c z_pwm.c z_sensor.c z_timer.c z_uart.c z_w25q64.c
